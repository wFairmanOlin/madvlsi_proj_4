v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/Documents/madvlsi_proj_4/schematic/ladder.sym} 320 30 0 0 {name=X1}
C {/home/madvlsi/Documents/madvlsi_proj_4/schematic/iout_mirror.sym} 450 70 0 0 {name=X2}
C {/home/madvlsi/Documents/madvlsi_proj_4/schematic/iout_mirror.sym} 450 360 0 0 {name=X3}
C {/home/madvlsi/Documents/madvlsi_proj_4/schematic/bias_current_resistive.sym} -60 -20 0 0 {name=X4}
C {/home/madvlsi/Documents/madvlsi_proj_4/schematic/cascode_generator.sym} -290 370 0 0 {name=X5}
