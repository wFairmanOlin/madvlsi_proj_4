v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/madvlsi/Desktop/madvlsi/madvlsi_proj_4/schematic/ladder.sym} 80 -20 0 0 {}
