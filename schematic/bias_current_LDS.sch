v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 370 -330 460 -330 { lab=vgate}
N 1680 -440 1700 -440 { lab=vp}
N 900 -440 920 -440 { lab=vp}
N 1080 -440 1120 -440 { lab=vp}
N 1100 -530 1100 -440 { lab=vp}
N 1480 -440 1520 -440 { lab=vp}
N 1280 -440 1320 -440 { lab=vp}
N 980 -440 1020 -440 { lab=Vbp}
N 1380 -440 1420 -440 { lab=#net1}
N 1580 -440 1620 -440 { lab=#net2}
N 950 -510 1050 -510 { lab=Vbp}
N 1650 -510 1650 -470 { lab=Vbp}
N 1650 -510 1830 -510 { lab=Vbp}
N 870 -530 910 -530 { lab=vp}
N 910 -530 1680 -530 { lab=vp}
N 1680 -530 1700 -530 { lab=vp}
N 1100 -200 1120 -200 { lab=vp}
N 1830 -510 2920 -510 { lab=Vbp}
N 1700 -440 1720 -440 { lab=vp}
N 1700 -530 2900 -530 { lab=vp}
N 1780 -440 1820 -440 { lab=#net2}
N 1880 -440 1920 -440 { lab=vp}
N 1980 -440 2020 -440 { lab=#net2}
N 2080 -440 2120 -440 { lab=vp}
N 2180 -440 2220 -440 { lab=#net2}
N 2280 -440 2320 -440 { lab=vp}
N 2380 -440 2420 -440 { lab=iout}
N 2480 -440 2520 -440 { lab=vp}
N 2580 -440 2620 -440 { lab=#net2}
N 2680 -440 2720 -440 { lab=vp}
N 2780 -440 2820 -440 { lab=#net2}
N 1850 -510 1850 -470 { lab=Vbp}
N 1750 -510 1750 -470 { lab=Vbp}
N 2050 -510 2050 -470 { lab=Vbp}
N 1950 -510 1950 -470 { lab=Vbp}
N 2250 -510 2250 -470 { lab=Vbp}
N 2150 -510 2150 -470 { lab=Vbp}
N 2450 -510 2450 -470 { lab=Vbp}
N 2350 -510 2350 -470 { lab=Vbp}
N 2650 -510 2650 -470 { lab=Vbp}
N 2550 -510 2550 -470 { lab=Vbp}
N 2850 -510 2850 -470 { lab=Vbp}
N 2750 -510 2750 -470 { lab=Vbp}
N 1600 -380 2800 -380 { lab=#net2}
N 1300 -40 1500 -40 { lab=vp}
N 1480 -200 1500 -200 { lab=vp}
N 3300 -530 3500 -530 { lab=vp}
N 3320 -510 3560 -510 { lab=Vbp}
N 3350 -510 3350 -470 { lab=Vbp}
N 2880 -440 2920 -440 { lab=vp}
N 2980 -440 3020 -440 { lab=#net2}
N 2900 -530 3300 -530 { lab=vp}
N 2920 -510 3320 -510 { lab=Vbp}
N 2950 -510 2950 -470 { lab=Vbp}
N 3050 -510 3050 -470 { lab=Vbp}
N 3150 -510 3150 -470 { lab=Vbp}
N 1500 -200 1520 -200 { lab=vp}
N 1500 -170 1550 -170 { lab=vp}
N 1580 -200 1620 -200 { lab=#net1}
N 1500 -40 3300 -40 { lab=vp}
N 3280 -200 3300 -200 { lab=vp}
N 3250 -170 3300 -170 { lab=vp}
N 3180 -200 3220 -200 { lab=#net1}
N 1680 -200 1720 -200 { lab=#net3}
N 1780 -200 1820 -200 { lab=#net1}
N 1880 -200 1920 -200 { lab=#net3}
N 1980 -200 2020 -200 { lab=#net1}
N 2080 -200 2120 -200 { lab=#net3}
N 2180 -200 2220 -200 { lab=#net1}
N 2280 -200 2320 -200 { lab=#net3}
N 2380 -200 2410 -200 { lab=#net1}
N 2410 -200 2420 -200 { lab=#net1}
N 2480 -200 2520 -200 { lab=#net3}
N 2580 -200 2620 -200 { lab=#net1}
N 2690 -200 2720 -200 { lab=#net3}
N 2680 -200 2690 -200 { lab=#net3}
N 2780 -200 2820 -200 { lab=#net1}
N 2880 -200 2920 -200 { lab=#net3}
N 2980 -200 3020 -200 { lab=#net1}
N 3080 -200 3120 -200 { lab=#net3}
N 1530 -130 2470 -130 { lab=#net1}
N 2470 -130 3150 -130 { lab=#net1}
N 1400 -260 3100 -260 { lab=#net3}
N 2400 -270 2400 -200 { lab=#net1}
N 2400 -280 2400 -270 { lab=#net1}
N 2400 -280 3000 -280 { lab=#net1}
N 2600 -280 2600 -200 { lab=#net1}
N 2800 -280 2800 -200 { lab=#net1}
N 3000 -220 3000 -200 { lab=#net1}
N 3000 -280 3200 -280 { lab=#net1}
N 3200 -280 3200 -200 { lab=#net1}
N 1600 -280 2400 -280 { lab=#net1}
N 1600 -280 1600 -200 { lab=#net1}
N 1800 -280 1800 -200 { lab=#net1}
N 2000 -280 2000 -200 { lab=#net1}
N 2200 -280 2200 -200 { lab=#net1}
N 3100 -250 3100 -200 { lab=#net3}
N 3100 -260 3100 -250 { lab=#net3}
N 2900 -260 2900 -200 { lab=#net3}
N 2700 -260 2700 -200 { lab=#net3}
N 2500 -260 2500 -200 { lab=#net3}
N 2300 -260 2300 -200 { lab=#net3}
N 2100 -260 2100 -200 { lab=#net3}
N 1900 -260 1900 -200 { lab=#net3}
N 1700 -250 1700 -200 { lab=#net3}
N 1700 -260 1700 -250 { lab=#net3}
N 1400 -260 1400 -200 { lab=#net3}
N 1380 -200 1420 -200 { lab=#net3}
N 1320 -150 1450 -150 { lab=#net2}
N 3000 -280 3000 -220 { lab=#net1}
N 3150 -170 3150 -150 { lab=#net1}
N 1310 -200 1320 -200 { lab=#net2}
N 1310 -150 1320 -150 { lab=#net2}
N 1280 -200 1290 -200 { lab=#net2}
N 1180 -200 1220 -200 { lab=#net4}
N 1150 -170 1150 -150 { lab=#net1}
N 1100 -40 1290 -40 { lab=vp}
N 1290 -40 1300 -40 { lab=vp}
N 1080 -200 1100 -200 { lab=vp}
N 1050 -170 1100 -170 { lab=vp}
N 900 -40 1100 -40 { lab=vp}
N 880 -200 900 -200 { lab=vp}
N 900 -200 920 -200 { lab=vp}
N 780 -200 820 -200 { lab=#net5}
N 700 -200 720 -200 { lab=vp}
N 700 -40 900 -40 { lab=vp}
N 700 -170 750 -170 { lab=vp}
N 980 -200 1020 -200 { lab=Vbp}
N 850 -170 850 -150 { lab=#net5}
N 850 -150 950 -150 { lab=#net5}
N 950 -170 950 -150 { lab=#net5}
N 800 -150 850 -150 { lab=#net5}
N 800 -200 800 -150 { lab=#net5}
N 1450 -510 1450 -470 { lab=Vbp}
N 1300 -470 1350 -470 { lab=vp}
N 2400 -200 2400 -150 { lab=#net1}
N 1300 -380 1300 -290 { lab=#net2}
N 1310 -380 1600 -380 { lab=#net2}
N 1200 -440 1220 -440 { lab=#net4}
N 1100 -470 1150 -470 { lab=vp}
N 1180 -440 1200 -440 { lab=#net4}
N 800 -440 810 -440 { lab=#net5}
N 1050 -490 1050 -470 { lab=#net4}
N 870 -510 950 -510 { lab=Vbp}
N 850 -510 870 -510 { lab=Vbp}
N 850 -510 850 -470 { lab=Vbp}
N 810 -440 820 -440 { lab=#net5}
N 880 -440 900 -440 { lab=vp}
N 700 -530 870 -530 { lab=vp}
N 640 -530 700 -530 { lab=vp}
N 780 -440 800 -440 { lab=#net5}
N 700 -440 720 -440 { lab=vp}
N 700 -530 700 -440 { lab=vp}
N 700 -470 750 -470 { lab=vp}
N 1350 -170 1350 -150 { lab=#net2}
N 1450 -170 1450 -150 { lab=#net2}
N 1150 -150 1150 -130 { lab=#net1}
N 3150 -150 3150 -130 { lab=#net1}
N 3050 -170 3050 -150 { lab=#net1}
N 3050 -150 3050 -130 { lab=#net1}
N 2950 -170 2950 -150 { lab=#net1}
N 2950 -150 2950 -130 { lab=#net1}
N 2850 -170 2850 -150 { lab=#net1}
N 2850 -150 2850 -130 { lab=#net1}
N 2750 -170 2750 -150 { lab=#net1}
N 2750 -150 2750 -130 { lab=#net1}
N 2650 -170 2650 -150 { lab=#net1}
N 2650 -150 2650 -130 { lab=#net1}
N 2550 -170 2550 -150 { lab=#net1}
N 2550 -150 2550 -130 { lab=#net1}
N 2450 -170 2450 -150 { lab=#net1}
N 2450 -150 2450 -130 { lab=#net1}
N 2350 -170 2350 -150 { lab=#net1}
N 2350 -150 2350 -130 { lab=#net1}
N 2250 -170 2250 -150 { lab=#net1}
N 2250 -150 2250 -130 { lab=#net1}
N 2150 -170 2150 -150 { lab=#net1}
N 2150 -150 2150 -130 { lab=#net1}
N 2050 -170 2050 -150 { lab=#net1}
N 2050 -150 2050 -130 { lab=#net1}
N 1950 -170 1950 -150 { lab=#net1}
N 1950 -150 1950 -130 { lab=#net1}
N 1850 -170 1850 -150 { lab=#net1}
N 1850 -150 1850 -130 { lab=#net1}
N 1750 -170 1750 -150 { lab=#net1}
N 1750 -150 1750 -130 { lab=#net1}
N 1650 -170 1650 -150 { lab=#net1}
N 1650 -150 1650 -130 { lab=#net1}
N 1150 -130 1530 -130 { lab=#net1}
N 2800 -380 3000 -380 { lab=#net2}
N 1500 -280 1600 -280 { lab=#net1}
N 900 -530 900 -440 { lab=vp}
N 800 -440 800 -340 { lab=#net5}
N 800 -340 800 -200 { lab=#net5}
N 900 -470 950 -470 { lab=vp}
N 1000 -440 1000 -340 { lab=Vbp}
N 1000 -340 1000 -200 { lab=Vbp}
N 1200 -440 1200 -400 { lab=#net4}
N 1200 -400 1200 -200 { lab=#net4}
N 1250 -490 1250 -470 { lab=#net4}
N 1200 -490 1200 -440 { lab=#net4}
N 1050 -490 1250 -490 { lab=#net4}
N 2300 -530 2300 -440 { lab=vp}
N 2100 -530 2100 -440 { lab=vp}
N 1900 -530 1900 -440 { lab=vp}
N 1700 -530 1700 -440 { lab=vp}
N 1050 -510 1650 -510 { lab=Vbp}
N 2400 -150 2400 -130 { lab=#net1}
N 1600 -440 1600 -380 { lab=#net2}
N 1800 -440 1800 -380 { lab=#net2}
N 2000 -440 2000 -380 { lab=#net2}
N 2200 -440 2200 -380 { lab=#net2}
N 3080 -440 3120 -440 { lab=vp}
N 3180 -440 3220 -440 { lab=#net2}
N 3280 -440 3320 -440 { lab=vp}
N 3200 -440 3200 -380 { lab=#net2}
N 2500 -530 2500 -440 { lab=vp}
N 3000 -380 3200 -380 { lab=#net2}
N 2400 -440 2400 -340 { lab=iout}
N 2400 -340 2430 -340 { lab=iout}
N 640 -40 700 -40 { lab=vp}
N 2700 -530 2700 -440 { lab=vp}
N 2900 -530 2900 -440 { lab=vp}
N 3100 -530 3100 -440 { lab=vp}
N 3000 -440 3000 -380 { lab=#net2}
N 2800 -440 2800 -380 { lab=#net2}
N 2600 -440 2600 -380 { lab=#net2}
N 3380 -440 3420 -440 { lab=#net1}
N 3500 -530 3500 -440 { lab=vp}
N 3450 -470 3500 -470 { lab=vp}
N 3200 -280 3300 -280 { lab=#net1}
N 3500 -530 4000 -530 { lab=vp}
N 4000 -530 4100 -530 { lab=vp}
N 4100 -530 4100 -440 { lab=vp}
N 4080 -440 4100 -440 { lab=vp}
N 4050 -470 4100 -470 { lab=vp}
N 3980 -440 4020 -440 { lab=#net5}
N 3880 -440 3920 -440 { lab=vp}
N 3780 -440 3820 -440 { lab=Vbp}
N 3680 -440 3720 -440 { lab=vp}
N 3580 -440 3620 -440 { lab=#net4}
N 3480 -440 3520 -440 { lab=vp}
N 3560 -510 4140 -510 { lab=Vbp}
N 3300 -40 4100 -40 { lab=vp}
N 4100 -200 4100 -110 { lab=vp}
N 4080 -200 4100 -200 { lab=vp}
N 4050 -170 4100 -170 { lab=vp}
N 3980 -200 4020 -200 { lab=#net5}
N 3880 -200 3920 -200 { lab=vp}
N 3780 -200 3820 -200 { lab=Vbp}
N 3680 -200 3720 -200 { lab=vp}
N 3580 -200 3620 -200 { lab=#net4}
N 3480 -200 3520 -200 { lab=#net2}
N 3380 -200 3420 -200 { lab=#net3}
N 3300 -200 3320 -200 { lab=vp}
N 1290 -200 1310 -200 { lab=#net2}
N 1300 -380 1310 -380 { lab=#net2}
N 1300 -290 1300 -200 { lab=#net2}
N 1300 -200 1300 -150 { lab=#net2}
N 1300 -150 1310 -150 { lab=#net2}
N 3100 -260 3400 -260 { lab=#net3}
N 3400 -260 3400 -200 { lab=#net3}
N 3500 -300 3500 -200 { lab=#net2}
N 3500 -380 3500 -300 { lab=#net2}
N 3200 -380 3500 -380 { lab=#net2}
N 3500 -200 3500 -150 { lab=#net2}
N 3350 -150 3500 -150 { lab=#net2}
N 3350 -170 3350 -150 { lab=#net2}
N 3450 -170 3450 -150 { lab=#net2}
N 3700 -170 3750 -170 { lab=vp}
N 3900 -200 3900 -110 { lab=vp}
N 3950 -170 3950 -150 { lab=#net5}
N 3850 -170 3850 -150 { lab=#net5}
N 3850 -150 3950 -150 { lab=#net5}
N 3950 -150 4000 -150 { lab=#net5}
N 4000 -200 4000 -150 { lab=#net5}
N 4000 -250 4000 -200 { lab=#net5}
N 3800 -260 3800 -200 { lab=Vbp}
N 3600 -260 3600 -200 { lab=#net4}
N 3750 -490 3750 -470 { lab=#net4}
N 3550 -490 3550 -470 { lab=#net4}
N 3600 -490 3600 -440 { lab=#net4}
N 3600 -400 3600 -260 { lab=#net4}
N 3600 -440 3600 -400 { lab=#net4}
N 3150 -130 3650 -130 { lab=#net1}
N 3650 -170 3650 -130 { lab=#net1}
N 3700 -530 3700 -440 { lab=vp}
N 3650 -470 3700 -470 { lab=vp}
N 3800 -440 3800 -340 { lab=Vbp}
N 3800 -340 3800 -260 { lab=Vbp}
N 3850 -470 3900 -470 { lab=vp}
N 3900 -530 3900 -440 { lab=vp}
N 4000 -440 4000 -340 { lab=#net5}
N 4000 -340 4000 -250 { lab=#net5}
N 4100 -110 4100 -40 { lab=vp}
N 3900 -110 3900 -40 { lab=vp}
N 3700 -200 3700 -40 { lab=vp}
N 3550 -170 3550 -40 { lab=vp}
N 3300 -200 3300 -40 { lab=vp}
N 1500 -200 1500 -40 { lab=vp}
N 1250 -170 1250 -40 { lab=vp}
N 1100 -200 1100 -40 { lab=vp}
N 900 -200 900 -40 { lab=vp}
N 700 -200 700 -40 { lab=vp}
N 950 -150 950 -90 { lab=#net5}
N 950 -90 3850 -90 { lab=#net5}
N 3850 -150 3850 -90 { lab=#net5}
N 3950 -510 3950 -470 { lab=Vbp}
N 1000 -510 1000 -440 { lab=Vbp}
N 3800 -510 3800 -440 { lab=Vbp}
N 1250 -490 3750 -490 { lab=#net4}
N 1300 -530 1300 -440 { lab=vp}
N 1400 -440 1400 -280 { lab=#net1}
N 1400 -280 1500 -280 { lab=#net1}
N 1500 -530 1500 -440 { lab=vp}
N 1500 -470 1550 -470 { lab=vp}
N 3400 -440 3400 -280 { lab=#net1}
N 3300 -280 3400 -280 { lab=#net1}
N 3300 -530 3300 -440 { lab=vp}
N 3250 -470 3300 -470 { lab=vp}
N 250 -200 290 -200 { lab=vp}
N 170 -200 190 -200 { lab=vp}
N 320 -230 320 -200 { lab=vgate}
N 320 -230 420 -230 { lab=vgate}
N 420 -230 420 -200 { lab=vgate}
N 350 -200 390 -200 { lab=vgate}
N 370 -230 370 -200 { lab=vgate}
N 370 -440 370 -230 { lab=vgate}
N 350 -440 370 -440 { lab=vgate}
N 370 -440 390 -440 { lab=vgate}
N 250 -440 290 -440 { lab=vp}
N 270 -530 270 -450 { lab=vp}
N 270 -450 270 -440 { lab=vp}
N 260 -530 270 -530 { lab=vp}
N 450 -200 490 -200 { lab=vp}
N 270 -200 270 -40 { lab=vp}
N 470 -200 470 -40 { lab=vp}
N 270 -40 470 -40 { lab=vp}
N 220 -230 220 -200 { lab=vgate}
N 220 -230 320 -230 { lab=vgate}
N 520 -230 520 -200 { lab=vgate}
N 420 -230 520 -230 { lab=vgate}
N 320 -510 320 -470 { lab=Vbp}
N 420 -510 420 -470 { lab=Vbp}
N 270 -530 470 -530 { lab=vp}
N 470 -530 470 -440 { lab=vp}
N 450 -440 470 -440 { lab=vp}
N 470 -440 490 -440 { lab=vp}
N 170 -530 170 -440 { lab=vp}
N 470 -530 540 -530 { lab=vp}
N 540 -530 550 -530 { lab=vp}
N 520 -470 550 -470 { lab=vp}
N 420 -510 590 -510 { lab=Vbp}
N 550 -440 570 -440 { lab=vp}
N 570 -530 570 -440 { lab=vp}
N 550 -530 570 -530 { lab=vp}
N 550 -470 570 -470 { lab=vp}
N 170 -440 190 -440 { lab=vp}
N 170 -470 220 -470 { lab=vp}
N 170 -440 170 -200 { lab=vp}
N 550 -200 570 -200 { lab=vp}
N 570 -440 570 -210 { lab=vp}
N 320 -170 320 -150 { lab=vp}
N 320 -150 420 -150 { lab=vp}
N 420 -170 420 -150 { lab=vp}
N 370 -150 370 -40 { lab=vp}
N 220 -170 220 -150 { lab=vp}
N 170 -150 220 -150 { lab=vp}
N 170 -200 170 -150 { lab=vp}
N 520 -170 520 -150 { lab=vp}
N 520 -150 570 -150 { lab=vp}
N 570 -200 570 -150 { lab=vp}
N 570 -210 570 -200 { lab=vp}
N 470 -40 640 -40 { lab=vp}
N 80 -40 270 -40 { lab=vp}
N 170 -530 260 -530 { lab=vp}
N 80 -530 170 -530 { lab=vp}
N 320 -510 420 -510 { lab=Vbp}
N 590 -510 850 -510 { lab=Vbp}
N 570 -530 640 -530 { lab=vp}
C {devices/opin.sym} 2430 -340 0 0 {name=p3 lab=iout}
C {devices/opin.sym} 4140 -510 0 0 {name=p4 lab=Vbp}
C {devices/opin.sym} 460 -330 0 0 {name=p5 lab=vgate}
C {madvlsi/pmos3.sym} 850 -440 1 0 {name=MP1a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3950 -440 1 0 {name=MP1b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1050 -440 1 0 {name=MP2a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3750 -440 1 0 {name=MP2b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1250 -440 1 0 {name=MP3a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3550 -440 1 0 {name=MP3b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1450 -440 1 0 {name=MP4a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3350 -440 1 0 {name=MP4b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 850 -200 3 0 {name=MN1a
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3950 -200 3 0 {name=MN1b
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 950 -200 3 0 {name=MN2a
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3850 -200 3 0 {name=MN2b
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1150 -200 3 0 {name=MN3a
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3650 -200 3 0 {name=MN3b
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1450 -200 3 0 {name=MN5a
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3350 -200 3 0 {name=MN5b
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1350 -200 3 0 {name=MN6a
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3450 -200 3 0 {name=MN6b
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2250 -440 1 0 {name=MP5g
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2550 -440 1 0 {name=MP5h
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1650 -440 1 0 {name=MP5a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1750 -440 1 0 {name=MP5b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1850 -440 1 0 {name=MP5c
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1950 -440 1 0 {name=MP5d
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2050 -440 1 0 {name=MP5e
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2150 -440 1 0 {name=MP5f
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2650 -440 1 0 {name=MP5i
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2750 -440 1 0 {name=MP5j
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2850 -440 1 0 {name=MP5k
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2950 -440 1 0 {name=MP5l
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3050 -440 1 0 {name=MP5m
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3150 -440 1 0 {name=MP5n
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 320 -440 1 0 {name=MP7a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1550 -200 3 0 {name=MDUM1
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1650 -200 3 0 {name=MN4a
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1750 -200 3 0 {name=MN4b
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1850 -200 3 0 {name=MN4c
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1950 -200 3 0 {name=MN4d
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2050 -200 3 0 {name=MN4e
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2150 -200 3 0 {name=MN4f
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2450 -200 3 0 {name=MN4i
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2250 -200 3 0 {name=MN4g
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2350 -200 3 0 {name=MN4h
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2550 -200 3 0 {name=MN4j
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2650 -200 3 0 {name=MN4k
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2750 -200 3 0 {name=MN4l
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2850 -200 3 0 {name=MN4m
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3150 -200 3 0 {name=MN4p
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 2950 -200 3 0 {name=MN4n
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3050 -200 3 0 {name=MN4o
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3250 -200 3 0 {name=MDUM2
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1250 -200 3 0 {name=MDUM3
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 1050 -200 3 0 {name=MDUM4
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 750 -200 3 0 {name=MDUM5
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1350 -440 1 0 {name=MDUM6
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1150 -440 1 0 {name=MDUM7
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 950 -440 1 0 {name=MDUM8
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 750 -440 1 0 {name=MDUM9
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 1550 -440 1 0 {name=MDUM10
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3250 -440 1 0 {name=MDUM11
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2350 -440 1 0 {name=MP6a
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 2450 -440 1 0 {name=MP6b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3450 -440 1 0 {name=MDUM12
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3650 -440 1 0 {name=MDUM13
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 3850 -440 1 0 {name=MDUM14
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 4050 -440 1 0 {name=MDUM15
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3550 -200 3 0 {name=MDUM16
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 3750 -200 3 0 {name=MDUM17
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 4050 -200 3 0 {name=MDUM18
L=2
W=5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 220 -440 1 0 {name=MDUM19
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 320 -200 3 0 {name=MPGa
L=2
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 420 -440 1 0 {name=MP7b
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 420 -200 3 0 {name=MPGb
L=2
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 520 -440 1 0 {name=MDUM22
L=2
W=5
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 220 -200 3 0 {name=MDUM23
L=2
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 520 -200 3 0 {name=MDUM24
L=2
W=5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} 80 -530 2 0 {name=p1 lab=vp}
C {devices/iopin.sym} 80 -40 2 0 {name=p2 lab=vn}
